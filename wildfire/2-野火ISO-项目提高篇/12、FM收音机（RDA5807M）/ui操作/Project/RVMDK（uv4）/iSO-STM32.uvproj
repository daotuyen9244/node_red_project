# Keil uVision project iSO-STM32.uvproj, settings and files
target 收音机 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\sdcard;..\..\User\ff9;..\..\User\lcd;..\..\User\SysTick;..\..\User\spi;..\..\User\led;..\..\User\key;..\..\User\rda5807m
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/usart/: bsp_usart1.c
    ../../User/sdcard/: bsp_sdio_sdcard.c bsp_sdfs_app.c bsp_bmp.c
    ../../User/lcd/: bsp_ili9341_lcd.c bsp_gpio_spi.c bsp_touch.c
    ../../User/spi/: bsp_spi_flash.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/led/: bsp_led.c
    ../../User/rda5807m/: bsp_rda5807m.c bsp_i2c_gpio.c
    ../../User/key/: bsp_key.c
  group DOC
    ../../Doc/: readme.txt
  group ff9
    ../../User/ff9/: diskio.c ff.c
    ../../User/ff9/option/: ccsbcs.c
